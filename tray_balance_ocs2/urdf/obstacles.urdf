Commit message: Add static obstacles.

File: tray_balance_ocs2/urdf/obstacles.urdf (robot description, URDF)
Before this commit: robot Obstacles, 1 links, 0 joints
Links:
- link obstacle1_link: geometry collision cylinder length=0.5 radius=0.25; visual cylinder length=0.5 radius=0.25
